# Keil uVision project 01 6-step plastik.uvprojx, settings and files
target 01 6-step plastik (6160000::V6.16::ARMCLANG)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801BFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: 01 6-step plastik +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ARM_MATH_CM4,USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32G431xx
  c include: ../Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../MCSDK_v6.3.0-Full/MotorControl/MCSDK/MCLib/Any/Inc;../MCSDK_v6.3.0-Full/MotorControl/MCSDK/MCLib/G4xx/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;..\Src
  memory RVCT4: ROM 0x8000000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User
    ../Src/: main.c motorcontrol.c pwm_common.c mc_api.c mc_config.c mc_config_common.c mcp_config.c mc_tasks.c mc_tasks_sixstep.c regular_conversion_manager.c mc_math.c mc_interface.c stm32_mc_common_it.c stm32g4xx_mc_it.c mc_parameters.c register_interface.c mcp.c usart_aspep_driver.c mc_configuration_registers.c aspep.c mc_app_hooks.c stm32g4xx_it.c stm32g4xx_hal_msp.c workspace.c led_module.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_ll_adc.c stm32g4xx_ll_dma.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_tim.c stm32g4xx_ll_usart.c stm32g4xx_ll_rcc.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Middlewares/MotorControl
    ../MCSDK_v6.3.0-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c ntc_temperature_sensor.c pid_regulator.c pwmc_sixstep.c r_divider_bus_voltage_sensor.c revup_ctrl_sixstep.c speed_pos_fdbk.c speed_ctrl.c virtual_speed_sensor.c mcpa.c potentiometer.c speed_potentiometer.c
    ../MCSDK_v6.3.0-Full/MotorControl/MCSDK/MCLib/G4xx/Src/: g4xx_bemf_ADC_fdbk.c
software components: CMSIS:CORE 5.6.0
